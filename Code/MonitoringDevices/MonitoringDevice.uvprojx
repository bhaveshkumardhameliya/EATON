# Keil uVision project MonitoringDevice.uvprojx, settings and files
target MonitoringDevices (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MonitoringDevices +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\STM32F0xx_HAL_Driver\Inc;.\Application;.\Configs;.\BSP_Common
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ./Application/: main.c ExceptionHandlers.c debugger.c TimerHandler.c MonitoringDeviceHandler.c
  group STM32F0xx_HAL_Driver
    ./STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_iwdg.c
  group Configs
    ./Configs/: stm32f0xx_hal_conf.h
  group BSP_Common
    ./BSP_Common/: GPIODriver.c IWDGDriver.c UARTDriver.c TIMDriver.c CRCDriver.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
